Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2019-02-18T12:38:05
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20140709_2115(x64) - Exporter 2014.0.2014.0709 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Feb 18 12:38:05 2019 * Host: BIM-HP * Database: C:\Users\dcole\AppData\Local\Temp\{B4914B50-186E-4DF9-9B8B-1348E401B549}\ifc * Database version: 5507 * Database creation date: Mon Feb 18 12:38:04 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Feb 18 12:38:04 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Feb 18 12:38:04 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: P:\Fastrack\53721_DOLPHIN SOLUTIONS LIMITED\ADDITIONAL DRAWINGS 2019 BIM\IFC\BCL636.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Identity Data - Structural: no; Name: Level 1; Building Story: yes
Dimensions - Computation Height: 0 mm
Graphics - Color: 0; Line Pattern: -3000010; Symbol at End 2 Default: yes; Symbol at End 1 Default: no; Line Weight: 1

# IfcBuildingElementProxy: BCL636 Dolphin Wall Plate Mounted Infrared Soap Dispenser, BCL636:BCL636 Dolphin Wall Plate Mounted Infrared Soap Dispenser:3705
In: Level 1
Material: Stainless Steel
Constraints - Level: Level: Level 1; Offset: 0 mm; Moves With Nearby Elements: no; Host: Level : Level 1
Phasing - Phase Created: New Construction
Dimensions - Volume: 0.000104083 m3; Capacity Soap: 1,000ml; Projection: 150mm; Width: Ø28mm
Pset_ManufacturerTypeInformation - Manufacturer: Dolphin Solutions Ltd.
Pset_BuildingElementProxyCommon - Reference: BCL636 Dolphin Wall Plate Mounted Infrared Soap Dispenser
Identity Data - Email: info@dolphinsolutions.co.uk; Description: Wall plate mounted infrared soap dispenser; URL: www.dolphinsolutions.co.uk; Address: Southpoint, Compass Park, Junction Road, Bodiam, TN32 5BS; Assembly Code: D2010900; Manufacturer: Dolphin Solutions Ltd.; Model: BCL636; Fax No.: +44 (0) 1424 205 200; Assembly Description: Other Plumbing Fixtures; Tel No.: +44 (0) 1424 202 224
General - Product Page Link: https://www.dolphinsolutions.co.uk/product/dolphin-wall-plate-mounted-infrared-soap-dispenser; Product Code: Polished finish = BCL636C - Brushed finish = BCL636S-2 - 316 Stainless stell = BCL636-316; Warranty: 2 years manufacturer's warranty; Product Data: Electronic soap dispenser activated by an infrared sensor. When the user places his hand within the sensor range, the soap dispenser delivers the soap. Soap Drop Portions: 0.7-0.9ml per drop portion (this is adjustable and depends on viscosity of soap). High quality polished chrome or brushed nickel-finish brass construction. Soap Container – 1,000ml. 2 year guarantee. Powered by 9v Transformer. Wall Mounted. Designed to match Dolphin Blue DB400 and DB1400 range taps. Important: please contact Dolphin Technical Helpline 01424 202224 /consult fitting instructions for design guidance. For panel mounted version see BCL632. Settings can be adjusted with a remote control (DB52). Power connections: soap dispenser: female / power source: male. Draws maximum current of 0.5A at sensor activation. To match this wall plate mounted soap dispenser with a wall plate mounted tap, we recommend our DS102 & DS104 InForm sensor taps.
Electrical - Power Source: 9V Transformer
